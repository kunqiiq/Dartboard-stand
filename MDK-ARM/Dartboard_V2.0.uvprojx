# Keil uVision project Dartboard_V2.0.uvprojx, settings and files
target Dartboard_V2.0 (::::)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Dartboard_V2_0 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../User/BSP;../User/CPU;../User/Driver;../User/Middleware;../User/Test;../User/Htim;../User/balance;../User/math;..\User\Flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CPU
    ../User/CPU/: scheduler.c scheduler.h
  group Middleware
    ../User/Middleware/: pid_service.c pid_service.h motor_service.c motor_service.h
  group Driver
    ../User/Driver/: PID.c PID.h DJI_motor.c DJI_motor.h servo.c servo.h
  group BSP
    ../User/BSP/: bsp_system.h bsp_can.c bsp_can.h bsp_uart.c bsp_uart.h bsp_pwm.c bsp_pwm.h
  group Test
    ../User/Test/: chassic_test.c chassic_test.h
  group Htim
    ../User/Htim/: tjc_hmi.c tjc_hmi.h tjc_hmi_stm32_hal.c tjc_hmi_stm32_hal.h dartboard_hmi.c dartboard_hmi.h page_fire.c page_fire.h page_balance.c page_balance.h page_record.c page_record.h
  group balance
    ../User/balance/: balance.c balance.h bmi088.c bmi088.h imu_attitude.c imu_attitude.h balance_motor.c balance_motor.h balance_app.c balance_app.h balance_pid.c balance_pid.h
    ../User/math/: drv_math.c drv_math.h
    ../User/Test/: auto_task.c auto_task.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group Flash
    ../User/Flash/: record_storage.c record_storage.h
software components: CMSIS:CORE 6.1.0
